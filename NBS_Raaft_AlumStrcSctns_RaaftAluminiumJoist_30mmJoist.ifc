Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2022-12-21T11:22:01
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.2.90.12 - Alternate UI 20.2.90.12
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Wed Dec 21 11:22:01 2022* Host: NCL-PI16* Database: C:\Users\haye\AppData\Local\Temp\c0356ae0-4664-40c0-8be0-7daa915de257\0b74d62d-367a-4315-a821-7b230007f0ba\ifc* Database version: 5507* Database creation date: Wed Dec 21 11:22:01 2022* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Wed Dec 21 11:22:01 2022* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Wed Dec 21 11:22:01 2022* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcBeam: 30mmJoist, NBS_Raaft_AluminiumStructuralSections_RaaftAluminiumJoist_30mmJoist:30mmJoist:326955
In: Level 0
Type - PredefinedType: BEAM
Type - BOS_General - Author: NBS; BIMObjectName: NBS_Raaft_AluminiumStructuralSections_RaaftAluminiumJoist_30mmJoist; ManufacturerName: Raaft; ManufacturerURL: www.raaft.co; NBSCertification: www.nationalbimlibrary.com/cert/klyws0ef; ProductInformation: n/a; Uniclass2015Title: Aluminium structural sections; Uniclass2015Code: Pr_20_76_51_07; Uniclass2015Version: Products v1.22; Version: 2
Type - NBS_Data - Colour: Silver; ContainsRedListMaterials: No; CountryOfMaterialOrigin: Europe; CountryOfProductManufacture: Europe; Recyclability: 100; RecycledContent: 35; StructuralSectionsFinishWorked: Mill finish; StructuralSectionsSize: 30 x 72 x 2400 mm
Type - IFC - IfcExportAs: IfcJoistType; IfcExportType: USERDEFINED
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_20_76_51_07:Aluminium structural sections; CodePerformance: n/a; Color: Silver,Brown; Constituents: n/a; Description: Aluminium support joists; DurationUnit: year; ExpectedLife: n/a; Features: Easy to install, shallow build up, supports green building certification, made from recycled products, lightweight, reduces need for ground levelling or steps, reduces the quantity of pedestals; Finish: Powder-coated; Grade: n/a; Manufacturer: enquiries@raaft.co; Material: Aluminium; ModelNumber: n/a; ModelReference: 30mmJoist; Name: AluminiumStructuralSections_RaaftAluminiumJoist_30mmJoist_Raaft; NominalHeight: 30 mm; NominalLength: 2400 mm; NominalWidth: 72 mm; ReplacementCost: n/a; Shape: Rectangle; Size: n/a; SustainabilityPerformance: 100% recyclable with 80% recycled content,; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Classification: Pr_20_76_51_07 (Uniclass2015); Material: Aluminium
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
